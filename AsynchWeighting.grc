options:
  parameters:
    generate_options: hb
    id: Asynch_Weighting
    output_language: python
    title: Asynch Weighting
  states: {}

blocks:
- name: Weights
  id: variable_function_probe
  parameters:
    block_id: WeightProbe
    function_name: level
    poll_rate: poll_rate
    value: (1,1,1,1)
  states: {}
- name: WeightProbe
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '4'
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Weights
    type: complex
    vlen: '4'
  states: {}
- name: blocks_vector_to_streams_0_1
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Output
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: RF
    type: complex
    vlen: '4'
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: Weights
    type: complex
    vlen: '4'
  states: {}
- name: poll_rate
  id: parameter
  parameters:
    label: poll_rate
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_add_xx_1_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_vector_to_streams_0_1, '0']
- [blocks_vector_to_streams_0_1, '0', blocks_add_xx_1_0, '0']
- [blocks_vector_to_streams_0_1, '1', blocks_add_xx_1_0, '1']
- [blocks_vector_to_streams_0_1, '2', blocks_add_xx_1_0, '2']
- [blocks_vector_to_streams_0_1, '3', blocks_add_xx_1_0, '3']
- [pad_source_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [pad_source_1, '0', WeightProbe, '0']

metadata:
  file_format: 1
