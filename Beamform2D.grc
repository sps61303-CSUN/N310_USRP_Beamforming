options:
  parameters:
    cmake_opt: '""'
    generate_options: qt_gui
    id: Beamform2D
    output_language: python
    title: Beamform2D
  states: {}

blocks:
- name: ARV_file
  id: variable
  parameters:
    value: '''/home/sawdust/Desktop/USRPdata/2Dsim/RectangularHalfLambda.cf64'''
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: beamforming_rate
  id: variable
  parameters:
    value: '30'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.425e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.25E6
  states: {}
- name: Asynch_Weighting_0
  id: Asynch_Weighting
  parameters:
    poll_rate: beamforming_rate*4
  states: {}
- name: Asynch_Weighting_0_0
  id: Asynch_Weighting
  parameters:
    poll_rate: beamforming_rate*4
  states: {}
- name: CovarianceMatrix_0
  id: CovarianceMatrix
  parameters:
    decimation: int(samp_rate/beamforming_rate)
  states: {}
- name: Drop_Samples_0
  id: Drop_Samples
  parameters:
    sample_window: '1024'
  states: {state: disabled}
- name: Video_Display_0
  id: Video_Display
  parameters:
    Display_Height: 256*4
    Display_Width: 256*4
    Input_Height: '256'
    Input_Width: '256'
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters:
    vlen: '4'
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/sawdust/Desktop/USRPdata/2Dsim/MovingRectangleSim.cf64
    repeat: 'True'
    type: complex
    vlen: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
    vlen: '4'
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '4'
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    ARV_file: ARV_file
    Color_Map: '''plasma'''
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from numpy import linalg as LA
      import matplotlib.pyplot as plt
      #from scipy.signal import find_peaks


      class blk(gr.sync_block):

        def __init__(self,ARV_file="/media/sf_ShareFolder/2Dsim/RectangularHalfLambda.cf64",Color_Map="plasma"):  # only default arguments here
          """arguments to this function show up as parameters in GRC"""
          gr.sync_block.__init__(
            self,
            name='Beam Pattern',   # will show up in GRC
            in_sig=[(np.complex64,4)],
            out_sig=[(np.int16,256*256*3)],
          )
          
          #Assemble the ARV from the vector input (4 by ARV_Length)
          self.ARV = np.fromfile(ARV_file,dtype=np.complex64).reshape(-1,4).T
          self.ARV_Length = len(self.ARV[1,:])
          
          #Set the color map for the video display
          self.cmap = plt.get_cmap(Color_Map)

        def work(self, input_items, output_items):
          for sampleIndex in range(len(input_items[0])):
            
            #Input the Weights
            Weights = input_items[0][sampleIndex]
            
            #Apply Weights to Arrival Matrix
            BeamPattern = np.abs(Weights.T @ self.ARV)
            
            #===========================Create Video Display===========================
            
            #Normalize BeamPattern from 0 to 1
            BeamPattern = BeamPattern/np.max(BeamPattern)
            
            #Apply color map and display the MUSIC Psuedospectrum
            RGB = self.cmap(BeamPattern)[:,:3] * 255
            
            #Convert from RGB to YUV
            Ychannel = (0.299 * RGB[:, 0] + 0.587 * RGB[:, 1] + 0.114 * RGB[:, 2]).astype(np.int16)
            Uchannel = (-0.147 * RGB[:, 0] - 0.289 * RGB[:, 1] + 0.436 * RGB[:, 2] + 128).astype(np.int16)
            Vchannel = (0.615 * RGB[:, 0] - 0.515 * RGB[:, 1] - 0.100 * RGB[:, 2] + 128).astype(np.int16)
            
            #Interleave Each Channel and write to output
            output_items[0][sampleIndex] = np.column_stack((Ychannel,Uchannel,Vchannel)).ravel()
            
          return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    ARV_file: ARV_file
    Color_Map: '''plasma'''
    N_signals: '2'
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from numpy import linalg as LA
      import matplotlib.pyplot as plt
      #import time

      class blk(gr.sync_block):

        def __init__(self,ARV_file="/home/sawdust/Desktop/USRPdata/2Dsim/RectangularHalfLambda.cf64",N_signals=2,Color_Map="plasma"):
        
          #Assemble the ARV from the vector input (4 by ARV_Length)
          self.ARV = np.fromfile(ARV_file,dtype=np.complex64).reshape(-1,4).T
          self.ARV_Length = len(self.ARV[1,:])
          
          gr.sync_block.__init__(
            self,
            name='MUSIC AOA and MVDR Weights',   # will show up in GRC
            in_sig=[(np.complex64,10)],
            out_sig=[(np.int16,self.ARV_Length*3),(np.complex64,4),(np.complex64,4)],
          )     
          
          #Determine the number of rows and columns of the square ARV
          self.Columns = int(np.sqrt(self.ARV_Length))
          self.Rows = int(self.ARV_Length/self.Columns)
          
          #Initialize the position of the two targets
          self.TargetCoords1 = np.array([0,0])
          self.TargetCoords2 = np.array([self.Rows,self.Columns])
          
          #Create the two sub-ARVs
          self.ARV1 = np.diag(np.array([1,1,0,0])) @ self.ARV
          self.ARV2 = np.diag(np.array([0,0,1,1])) @ self.ARV
          
          #Define the number of signals being searched for
          self.Signals = N_signals
          
          #Create the Circle that blocks out the first peak
          x,y = np.meshgrid(np.arange(-10,11), np.arange(-10,11))
          R = np.sqrt(np.square(x)+np.square(y)).flatten()
          self.Block = (x.flatten()+y.flatten()*self.Columns)[np.where(R<=10)]
          
          #Set the color map for the video display
          cmap = plt.get_cmap(Color_Map)
          
          #Convert the color map from RGB to YUV
          RGB = cmap(np.linspace(0,1,256))[:,:3]*255
          self.YUV = np.zeros((256,3),np.int16)
          self.YUV[:,0] = (0.299 * RGB[:, 0] + 0.587 * RGB[:, 1] + 0.114 * RGB[:, 2]).astype(np.int16)
          self.YUV[:,1] = (-0.147 * RGB[:, 0] - 0.289 * RGB[:, 1] + 0.436 * RGB[:, 2] + 128).astype(np.int16)
          self.YUV[:,2] = (0.615 * RGB[:, 0] - 0.515 * RGB[:, 1] - 0.100 * RGB[:, 2] + 128).astype(np.int16)
          
        def work(self, input_items, output_items):
           
          for sampleIndex in range(len(input_items[0])):
          
            #t0 = time.time()
            #=========================Receive Data============================
            
            #Assemble Upper Triangular Cross Correlation Matrix (4 by 4)
            Rxx = np.zeros((4,4), dtype=np.complex64)
            Rxx[np.triu_indices(4)] = input_items[0][sampleIndex]
            
            #Compute Eigendecomposition
            Eigvals, U = LA.eigh(Rxx,"U")
            U = U[:,np.argsort(Eigvals)]
            Eigvals = np.sort(Eigvals)
            
            #Compute Noise Subspace
            U_n = U[:,:(4-self.Signals)]
            P_n = U_n @ np.conj(U_n.T)
            
            #Compute Signal Subspace
            U_s = U[:,(4-self.Signals):4]
            
            #=======================Phase Correction==========================
            
            #Compute the Collinearity in pieces
            BaseCollinearity = np.sum(np.conj(self.ARV) * (P_n @ self.ARV), axis=0)
            ErrorComponent = 2*np.sum(np.conj(self.ARV2) * (P_n @ self.ARV1), axis=0)
            
            #Assume the ErrorComponent always has the ideal phase to compute BestCaseCollinearity
            CleanComponent = BaseCollinearity - np.real(ErrorComponent)
            BestCaseCollinearity = np.abs(CleanComponent - np.abs(ErrorComponent))
            
            #Compute Phase Error using signal peak
            PhaseError = np.angle(-1*ErrorComponent[np.argmin(BestCaseCollinearity)])
            
            #Compute the complex number needed to offset the phase error
            Shift = np.exp(1j*PhaseError)
            
            #==========================MUSIC AOA==============================
            
            #Compute the True Collinearity by shifting the error component
            TrueCollinearity = np.abs(CleanComponent + np.real(ErrorComponent*np.conj(Shift)))
             
            #Compute the MUSIC Psuedospectrum using the True Collinearity
            PMUSIC = np.where(TrueCollinearity == 0, 100, np.log10(1 / TrueCollinearity))
            
            #Find the first AOA
            PeakIndex1 = np.argmin(TrueCollinearity)
            
            #Block out the area around the first peak and find the next highest point
            Block = self.Block+PeakIndex1
            Block_bounded = Block[Block<self.ARV_Length]
            TrueCollinearity[Block_bounded] = 1
            PeakIndex2 = np.argmin(TrueCollinearity) 
            
            #======================Maintain Target Lock=======================
            
            #Convert indices into 2d coordinates
            PeakCoords1 = np.array(np.unravel_index(PeakIndex1,(self.Rows,self.Columns)))
            PeakCoords2 = np.array(np.unravel_index(PeakIndex2,(self.Rows,self.Columns)))
            
            #Compare the square of the distances between each pairs of points
            Error1 = np.sum(np.square(PeakCoords1-self.TargetCoords1)+np.square(PeakCoords2-self.TargetCoords2))
            Error2 = np.sum(np.square(PeakCoords1-self.TargetCoords2)+np.square(PeakCoords2-self.TargetCoords1))
            
            #Update the target coordinates with the closest new coordinates
            if Error1<=Error2:
              self.TargetCoords1 = PeakCoords1
              self.TargetCoords2 = PeakCoords2
            else:
              self.TargetCoords1 = PeakCoords2
              self.TargetCoords2 = PeakCoords1
              #Swap the two indices
              PeakIndex1,PeakIndex2 = PeakIndex2,PeakIndex1
                   
            #=======================MVDR Beamforming==========================
            
            #Create the signal subspace projection and phase correction matrix
            CorrectionMatrix = U_s @ np.conj(U_s.T) @ np.diag(np.array([1,1,Shift,Shift]))
            
            #Phase correct the arrival vector associated with each peak and project it onto the signal subspace
            a1 = CorrectionMatrix @ self.ARV[:,PeakIndex1]
            a2 = CorrectionMatrix @ self.ARV[:,PeakIndex2]
            
            #Compute the inverse of the eigenvalues
            EigvalsInv = np.where(Eigvals == 0, 1e30, 1/Eigvals)
                
            #Compute the inverse of the cross correlation matrix
            InvRxx = U @ np.diag(EigvalsInv) @ np.conj(U.T)
            
            #Create MVDR Weights using the projected arrival vectors
            output_items[1][sampleIndex] = np.conj(InvRxx @ a1[:,None]).flatten() #/ (np.conj(a1[:,None].T) @ InvRxx @ a1[:,None])
            output_items[2][sampleIndex] = np.conj(InvRxx @ a2[:,None]).flatten() #/ (np.conj(a2[:,None].T) @ InvRxx @ a2[:,None])
            
            #======================Create Video Display=======================
            
            #Normalize MUSIC spectrum from 0 to 255
            AOAplot = (255*PMUSIC/np.max(PMUSIC)).astype(np.int16)
            #AOAplot[np.ravel_multi_index(self.TargetCoords1,(self.Rows,self.Columns))] = 0
            #AOAplot[np.ravel_multi_index(self.TargetCoords2,(self.Rows,self.Columns))] = 0
            #AOAplot[Block_bounded] = 0
            
            #Apply color map and write to the video output
            output_items[0][sampleIndex] = self.YUV[AOAplot,:].flatten()
            #print(time.time()-t0)
            
          return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color4: magenta
    grid: 'True'
    label1: RF0
    label2: RF1
    label3: RF2
    label4: RF3
    name: '"In-Phase Time Plot"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: 1/24
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ylabel: Volts
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: I
    label2: Q
    name: '"MVDR Output 2"'
    size: '128'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: 1/4
    width1: '2'
    width2: '2'
    ylabel: Volts
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: I
    label2: Q
    name: '"MVDR Output 1"'
    size: '512'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"snr"'
    type: complex
    update_time: 1/20
    width1: '2'
    width2: '2'
    ylabel: Volts
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    bw0: bandwidth
    bw1: bandwidth
    bw2: bandwidth
    bw3: bandwidth
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_source0: internal
    dev_addr: addr=192.168.10.2
    dev_args: rx_lo_source=internal,init_cals=BASIC|TX_ATTENUATION_DELAY|RX_GAIN_DELAY|PATH_DELAY|TX_LO_LEAKAGE_INTERNAL|LOOPBACK_RX_LO_DELAY
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: '"A:0 A:1 B:0 B:1"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: RF
  states: {state: disabled}

connections:
- [Asynch_Weighting_0, '0', qtgui_time_sink_x_0_1, '0']
- [Asynch_Weighting_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [CovarianceMatrix_0, '0', epy_block_0_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_vector_to_streams_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_streams_to_vector_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_streams_0_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_vector_to_streams_0_0, '2', qtgui_time_sink_x_0_0, '2']
- [blocks_vector_to_streams_0_0, '3', qtgui_time_sink_x_0_0, '3']
- [epy_block_0_0, '0', Video_Display_0, '0']
- [epy_block_0_0, '1', Asynch_Weighting_0, '1']
- [epy_block_0_0, '2', Asynch_Weighting_0_0, '1']
- [uhd_usrp_source_0, '0', blocks_streams_to_vector_0, '0']
- [uhd_usrp_source_0, '1', blocks_streams_to_vector_0, '1']
- [uhd_usrp_source_0, '2', blocks_streams_to_vector_0, '2']
- [uhd_usrp_source_0, '3', blocks_streams_to_vector_0, '3']
- [virtual_source_0_0_0, '0', CovarianceMatrix_0, '0']
- [virtual_source_0_0_0_0, '0', Asynch_Weighting_0, '0']
- [virtual_source_0_0_0_0_0, '0', Asynch_Weighting_0_0, '0']
- [virtual_source_0_0_1, '0', blocks_complex_to_real_0_0, '0']

metadata:
  file_format: 1
