options:
  parameters:
    cmake_opt: '""'
    generate_options: qt_gui
    id: ArrayScan
    output_language: python
    title: ArrayScan
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: beamforming_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.25E6*2
  states: {}
- name: CovarianceMatrix_0
  id: CovarianceMatrix
  parameters:
    decimation: int(samp_rate/beamforming_rate)
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: '4'
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: '6'
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters:
    vlen: '3'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/sf_ShareFolder/10100MHz/Raw10100ARV.cf64
    type: complex
    vlen: '6'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /media/sf_ShareFolder/10100MHz/10100ARVposition.cf64
    type: complex
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/sawdust/Desktop/USRPdata/10100MHz/10100AzSweep.cf64
    repeat: 'True'
    type: complex
    vlen: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
    vlen: '4'
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '4'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: blocks_vector_to_streams_1
  id: blocks_vector_to_streams
  parameters:
    num_streams: '6'
    type: float
  states: {}
- name: blocks_vector_to_streams_2
  id: blocks_vector_to_streams
  parameters:
    num_streams: '3'
    type: float
  states: {}
- name: epy_block_2_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from numpy import linalg as LA
      import time

      class blk(gr.sync_block):

        def __init__(self):  # only default arguments here
          """arguments to this function show up as parameters in GRC"""
          #Set the starting time
          self.t0 = time.time()
          
          gr.sync_block.__init__(
              self,
              name='Dominant Eigenvector\nand Eigenvalue',   # will show up in GRC
              in_sig=[(np.complex64,10)],
              out_sig=[(np.complex64,6)]
          )

        def work(self, input_items, output_items):  
          for sampleIndex in range(len(input_items[0])):
            #Output Time Stamp
            output_items[0][sampleIndex][5] = time.time()-self.t0
            
            #Assemble Upper Triangular Cross Correlation Matrix (4 by 4)
            Rxx = np.zeros((4,4), dtype=np.complex64)
            Rxx[np.triu_indices(4)] = input_items[0][sampleIndex]
            
            #Compute Eigen Decomposition
            Eigvals, U = LA.eigh(Rxx,"U")
            
            #Output Dominant Eigenvector
            output_items[0][sampleIndex][0:4] = U[:,np.argmax(Eigvals)]
            
            #Output Dominant Eigenvalue
            output_items[0][sampleIndex][4] = np.max(Eigvals)
                 
          return len(output_items[0])
  states: {}
- name: epy_block_2_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import serial
      import time

      class blk(gr.sync_block):

        def __init__(self):  # only default arguments here
          
          #Set the starting time
          self.t0 = time.time()
          
          #Initialize IO
          gr.sync_block.__init__(
              self,
              name='Position Controller',   # will show up in GRC
              in_sig=None,
              out_sig=[(np.complex64,3)]
          )
          
          #Define roll angle Targets
          self.roll = np.linspace(-90.0,90.0,5)
          
          #Set the setup flag to True
          self.setup = True
          
          #Set the sweeping_right flag to True
          self.sweeping_right = True
          
          #Set the starting index for the roll array
          self.roll_index = 0
          
          #Initialize the serial port object
          self.MI4190 = serial.Serial()
          self.MI4190.baudrate = 9600
          self.MI4190.port = '/dev/ttyUSB0'
          self.MI4190.timeout = 1

        def work(self, input_items, output_items):
      	#=======================Function Definitions========================
          def move_azimuth(az):
            self.MI4190.write(f'CONT1:AXIS(1):POS:COMM {az:.2f}\r'.encode())
            self.MI4190.write(b'CONT1:AXIS(1):MOT:STAR\r')
          
          def read_azimuth():
            self.MI4190.write(b'CONT1:AXIS(1):POS:CURR?\r')
            return float(self.MI4190.readline().decode('utf-8'))
            
          def move_roll(phi):  
            self.MI4190.write(f'CONT1:AXIS(2):POS:COMM {phi:.2f}\r'.encode())
            self.MI4190.write(b'CONT1:AXIS(2):MOT:STAR\r')
            
          def read_roll():
            self.MI4190.write(b'CONT1:AXIS(2):POS:CURR?\r')
            return float(self.MI4190.readline().decode('utf-8'))
          
          def setup_procedure():
            #Open the serial connection to the turntable, halt if it fails
            print("Opening Serial Connection...")
            try:
              self.MI4190.open()
            except:
              print(f'Error: Serial Port {self.MI4190.port} Not Open')
              return -1
      		  
            #IDK what this does but it's necessary
            self.MI4190.write(b'++mode 1\r')
            self.MI4190.write(b'++addr 4\r')
            self.MI4190.write(b'++auto 1\r')
            self.MI4190.write(b'++eoi 1\r')
            
            #Pull the IDN to make sure it's connected, otherwise halt
            self.MI4190.write(b'*IDN?\r')
            IDN = self.MI4190.readline()
            if len(IDN) == 0:
              print("Error: Serial Connection Failed")
              return -1
            print(IDN.decode('utf-8'))
            
            #Move the chamber to the initial position
            print("Moving Into Initial Position...")
            move_azimuth(-100.0)
            
            #Check until the turntable is in position
            Az = 0.0
            while Azimuth > -95.0:
              Azimuth = read_azimuth()
              time.sleep(0.1)
              
            #Start the turntable swinging to 100 degrees
            move_azimuth(100.0)
            print(f"Executing Sweep 0/{len(self.roll)}...")
            
            #Set the setup flag to false
            self.setup = False
            return 0
            
          def reset_procedure():
            print("Resetting Test Chamber...")
            
            #Start the turntable swinging to 0 degrees
            move_azimuth(0.0)
            
            #Turn the roll axis back to 0 degrees
            ########
            
            #Close the serial connection and return -1 to halt
            self.MI4190.close()
            return -1
            
          #========================Work Loop Start============================
          #Perform initial setup on first loop
          if self.setup:
            return setup_procedure()
          
          #Determine Azimuth position
          Azimuth = read_azimuth()
          output_items[0][0][0] = Azimuth
          
          #Determine Roll position
          Roll = read_roll()
          output_items[0][0][1] = Roll
          
          #Output Time Stamp
          output_items[0][0][2] = time.time() - self.t0
          
          #Check if a left sweep is complete
          if (Azimuth < -95.0) and (not self.sweeping_right):
            #Increment to the next roll position
            self.roll_index+=1
            
            #Start the turntable swinging to 100 degrees
            move_azimuth(100.0)
            print(f"Executing Sweep {self.roll_index}/{len(self.roll)}...")
            self.sweeping_right = True
            
            #Check if all roll angles have been visited
            if self.roll_index >= len(self.roll):
              return reset_procedure()
          
          #Check if a right sweep is complete
          elif (Azimuth > 95.0) and self.sweeping_right:
            #Increment to the next roll position
            self.roll_index+=1
            
            #Start the turntable swinging to -100 degrees
            move_azimuth(-100.0)
            print(f"Executing Sweep {self.roll_index}/{len(self.roll)}...")
            self.sweeping_right = False
            
            #Check if all roll angles have been visited
            if self.roll_index >= len(self.roll):
              return reset_procedure()
              
          #Wait some time to limit the loop speed
          time.sleep(0.01)
          
          return 1
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Time2
    max: '30'
    min: '0'
    type: float
    update_time: 1/100
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Time1
    max: '30'
    min: '0'
    type: float
    update_time: 1/100
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color4: magenta
    grid: 'True'
    label1: RF0
    label2: RF1
    label3: RF2
    label4: RF3
    name: '"In-Phase Time Plot"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: 1/8
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ylabel: Volts
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: beamforming_rate
    srate: beamforming_rate
    type: float
    update_time: 1/2
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    bw0: bandwidth
    bw1: bandwidth
    bw2: bandwidth
    bw3: bandwidth
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_source0: internal
    dev_addr: addr=192.168.10.2
    dev_args: rx_lo_source=internal,init_cals=BASIC|TX_ATTENUATION_DELAY|RX_GAIN_DELAY|PATH_DELAY|TX_LO_LEAKAGE_INTERNAL|LOOPBACK_RX_LO_DELAY
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: '"A:0 A:1 B:0 B:1"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}

connections:
- [CovarianceMatrix_0, '0', epy_block_2_1_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_complex_to_real_1, '0', blocks_vector_to_streams_1, '0']
- [blocks_complex_to_real_2, '0', blocks_vector_to_streams_2, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_streams_to_vector_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_streams_0, '2', qtgui_time_sink_x_0, '2']
- [blocks_vector_to_streams_0, '3', qtgui_time_sink_x_0, '3']
- [blocks_vector_to_streams_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_to_streams_1, '1', qtgui_time_sink_x_2, '1']
- [blocks_vector_to_streams_1, '2', qtgui_time_sink_x_2, '2']
- [blocks_vector_to_streams_1, '3', qtgui_time_sink_x_2, '3']
- [blocks_vector_to_streams_1, '4', qtgui_time_sink_x_2, '4']
- [blocks_vector_to_streams_1, '5', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_2, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_2, '1', blocks_null_sink_0, '1']
- [blocks_vector_to_streams_2, '2', qtgui_number_sink_0_0, '0']
- [epy_block_2_1_0_0, '0', blocks_complex_to_real_1, '0']
- [epy_block_2_1_0_0, '0', blocks_file_sink_0, '0']
- [epy_block_2_1_0_0_0, '0', blocks_complex_to_real_2, '0']
- [epy_block_2_1_0_0_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_streams_to_vector_0, '0']
- [uhd_usrp_source_0, '1', blocks_streams_to_vector_0, '1']
- [uhd_usrp_source_0, '2', blocks_streams_to_vector_0, '2']
- [uhd_usrp_source_0, '3', blocks_streams_to_vector_0, '3']
- [virtual_source_0_0_0, '0', CovarianceMatrix_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
