options:
  parameters:
    generate_options: hb
    id: Video_Display
    output_language: python
    title: Video Display
  states: {}

blocks:
- name: Display_Height
  id: parameter
  parameters:
    label: Display Height
    type: intx
    value: '1024'
  states: {}
- name: Display_Width
  id: parameter
  parameters:
    label: Display Width
    type: intx
    value: '1024'
  states: {}
- name: Input_Height
  id: parameter
  parameters:
    label: Input Height
    type: intx
    value: '256'
  states: {}
- name: Input_Width
  id: parameter
  parameters:
    label: Input Width
    type: intx
    value: '256'
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: short
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Input_Width*Input_Height*3
    type: short
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: short
    vlen: Input_Width*Input_Height*3
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: Display_Height
    display_width: Display_Width
    fps: '0'
    height: Input_Height
    num_channels: '3'
    type: short
    width: Input_Width
  states: {}

connections:
- [blocks_stream_to_streams_0, '0', video_sdl_sink_0, '0']
- [blocks_stream_to_streams_0, '1', video_sdl_sink_0, '1']
- [blocks_stream_to_streams_0, '2', video_sdl_sink_0, '2']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_streams_0, '0']
- [pad_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
