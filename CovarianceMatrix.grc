options:
  parameters:
    generate_options: hb
    id: CovarianceMatrix
    output_language: python
    title: Covariance Matrix
  states: {}

blocks:
- name: FractionalBW
  id: variable
  parameters:
    value: 1/int(np.sqrt(decimation))
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_2
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_3
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_4
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_5
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_6
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_7
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_8
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_9
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '10'
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: decimation
    type: intx
    value: '52000'
  states: {}
- name: import_0
  id: import
  parameters: {}
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Rxx
    type: complex
    vlen: '10'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: RF
    type: complex
    vlen: '4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: int(np.sqrt(decimation))
    fbw: FractionalBW
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RF0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RF1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RF3
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: RF2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: R11
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: R12
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R13
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R14
  states: {}
- name: virtual_sink_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R23
  states: {}
- name: virtual_sink_1_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R24
  states: {}
- name: virtual_sink_1_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R34
  states: {}
- name: virtual_sink_1_0_0_1_1
  id: virtual_sink
  parameters:
    stream_id: R33
  states: {}
- name: virtual_sink_1_0_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: R44
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: R22
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RF0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RF0
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF2
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF3
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: RF2
  states: {}
- name: virtual_source_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: RF3
  states: {}
- name: virtual_source_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: RF3
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: RF0
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: RF0
  states: {}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: RF1
  states: {}
- name: virtual_source_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: RF1
  states: {}
- name: virtual_source_0_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: RF2
  states: {}
- name: virtual_source_0_0_1_1_1
  id: virtual_source
  parameters:
    stream_id: RF2
  states: {}
- name: virtual_source_0_0_1_1_1_0
  id: virtual_source
  parameters:
    stream_id: RF3
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: RF1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: R11
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: R12
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: R14
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: R24
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R34
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R44
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: R22
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: R13
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: R23
  states: {}
- name: virtual_source_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: R33
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', virtual_sink_1, '0']
- [blocks_multiply_conjugate_cc_1, '0', virtual_sink_1_0, '0']
- [blocks_multiply_conjugate_cc_2, '0', virtual_sink_1_1, '0']
- [blocks_multiply_conjugate_cc_3, '0', virtual_sink_1_0_0, '0']
- [blocks_multiply_conjugate_cc_4, '0', virtual_sink_1_0_0_1, '0']
- [blocks_multiply_conjugate_cc_5, '0', virtual_sink_1_0_0_1_1, '0']
- [blocks_multiply_conjugate_cc_6, '0', virtual_sink_1_0_0_0, '0']
- [blocks_multiply_conjugate_cc_7, '0', virtual_sink_1_0_0_1_0, '0']
- [blocks_multiply_conjugate_cc_8, '0', virtual_sink_1_0_0_1_0_0, '0']
- [blocks_multiply_conjugate_cc_9, '0', virtual_sink_1_0_0_1_1_0, '0']
- [blocks_streams_to_vector_0, '0', pad_sink_0, '0']
- [blocks_vector_to_streams_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_streams_0, '1', virtual_sink_0_0, '0']
- [blocks_vector_to_streams_0, '2', virtual_sink_0_1, '0']
- [blocks_vector_to_streams_0, '3', virtual_sink_0_0_0, '0']
- [pad_source_0, '0', blocks_vector_to_streams_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_streams_to_vector_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_streams_to_vector_0, '1']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_streams_to_vector_0, '2']
- [rational_resampler_xxx_0_0_1, '0', blocks_streams_to_vector_0, '3']
- [rational_resampler_xxx_0_0_1_0, '0', rational_resampler_xxx_0_0_1_0_0, '0']
- [rational_resampler_xxx_0_0_1_0_0, '0', blocks_streams_to_vector_0, '4']
- [rational_resampler_xxx_0_0_1_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0_0_0_0, '0', blocks_streams_to_vector_0, '5']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0, '0', blocks_streams_to_vector_0, '6']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0, '0', blocks_streams_to_vector_0, '7']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0, '0', blocks_streams_to_vector_0, '8']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0_0_0, '0', blocks_streams_to_vector_0, '9']
- [rational_resampler_xxx_0_1, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_1_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [rational_resampler_xxx_0_2, '0', rational_resampler_xxx_0_0_1, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_0_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [virtual_source_0_0_0_0, '0', blocks_multiply_conjugate_cc_3, '1']
- [virtual_source_0_0_0_0_0, '0', blocks_multiply_conjugate_cc_6, '1']
- [virtual_source_0_0_0_0_1, '0', blocks_multiply_conjugate_cc_4, '1']
- [virtual_source_0_0_0_0_1_0, '0', blocks_multiply_conjugate_cc_7, '1']
- [virtual_source_0_0_0_0_1_0_0, '0', blocks_multiply_conjugate_cc_8, '1']
- [virtual_source_0_0_1, '0', blocks_multiply_conjugate_cc_3, '0']
- [virtual_source_0_0_1_0, '0', blocks_multiply_conjugate_cc_6, '0']
- [virtual_source_0_0_1_1, '0', blocks_multiply_conjugate_cc_4, '0']
- [virtual_source_0_0_1_1_0, '0', blocks_multiply_conjugate_cc_7, '0']
- [virtual_source_0_0_1_1_0_0, '0', blocks_multiply_conjugate_cc_8, '0']
- [virtual_source_0_0_1_1_1, '0', blocks_multiply_conjugate_cc_5, '0']
- [virtual_source_0_0_1_1_1, '0', blocks_multiply_conjugate_cc_5, '1']
- [virtual_source_0_0_1_1_1_0, '0', blocks_multiply_conjugate_cc_9, '0']
- [virtual_source_0_0_1_1_1_0, '0', blocks_multiply_conjugate_cc_9, '1']
- [virtual_source_0_1, '0', blocks_multiply_conjugate_cc_2, '0']
- [virtual_source_0_1, '0', blocks_multiply_conjugate_cc_2, '1']
- [virtual_source_1, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1_0, '0', rational_resampler_xxx_0_1, '0']
- [virtual_source_1_0_0, '0', rational_resampler_xxx_0_2, '0']
- [virtual_source_1_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0, '0']
- [virtual_source_1_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0, '0']
- [virtual_source_1_0_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0_0_0_0_0, '0']
- [virtual_source_1_0_1, '0', rational_resampler_xxx_0_0_1_0, '0']
- [virtual_source_1_1, '0', rational_resampler_xxx_0_1_0, '0']
- [virtual_source_1_1_0, '0', rational_resampler_xxx_0_0_1_0_0_0, '0']
- [virtual_source_1_1_0_0, '0', rational_resampler_xxx_0_0_1_0_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
